# Keil uVision project TheraLaseTLC2000.uvprojx, settings and files
target TheraLaseTLC2000 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: TheraLaseTLC2000 +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL,USE_DFU,NEW_BOARD, ENABLE_iWATCHDOG,LOGO_ENABLED, BOARD_R4
  c include: .\Libraries\CMSIS\Device\ST\STM32F10x\Include;.\inc;.\inc\STM32_TLC2000;.\src\UTFT;.\src\UTFT_DLB;.\Libraries\CMSIS\Include;.\Libraries\StdPeriph_Driver\inc;.\Libraries\USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x7c800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./src/: main.c hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c misc.c
  group CMSIS
    ./src/: system_stm32f10x.c
    ./Libraries/StartUp/: startup_stm32f10x_hd.s
  group USB-Device_Driver
    ./Libraries/USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group StdPeriph_Driver
    ./Libraries/StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c
  group TLC2000
    ./src/STM32_TLC2000/: fnt08x08.c stm3210e_TLC2000.c RTC.c FPGA_RAM.c Potentiometer.c ADS8319_ADC.c MiscTools.c Hid_command_process.c calibration.c TLC2000_SPI_LCD_TFT.c fonts.c DAC7718.c Switch2.c tBT.c Buzzer.c CPU_ADC.c firmwareUpdate.c BatSensor.c
    ./src/all_Fonts/: SevenSegNumFontPlus32x50.c hallfetica_normal16x16.c
  group UTFT
    ./src/UTFT/: UTFT.c theralaseImage320x240.c theralase240x60Flip.c
    ./src/UTFT_DLB/: UTFT_DLB.c UTFT_DLB_Demo.c DejaVuSans18.c Arial12.c arial14.c arial16.c arial15.c
  group Doc
    ./: history.txt
target TheraLaseTLC2000_debug (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: TheraLaseTLC2000_debug +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL,USE_DFU,NEW_BOARD, ENABLE_iWATCHDOG,LOGO_ENABLEDx, BOARD_R4
  c include: .\inc;.\src\UTFT;.\src\UTFT_DLB;.\inc\STM32_TLC2000;.\Libraries\CMSIS\Include;.\Libraries\StdPeriph_Driver\inc;.\Libraries\USB-FS-Device_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F10x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x7c800
  memory RVCT9: RAM 0x20000000 size 0x10000
target Debug (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: TheraLaseTLC2000 +hex
  c flags: OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL,USE_DFUx,NEW_BOARD, ENABLE_iWATCHDOGx,LOGO_ENABLEDx, BOARD_R4
  c include: .\Libraries\CMSIS\Device\ST\STM32F10x\Include;.\inc;.\inc\STM32_TLC2000;.\src\UTFT;.\src\UTFT_DLB;.\Libraries\CMSIS\Include;.\Libraries\USB-FS-Device_Driver\inc;.\Libraries\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4ff80
  memory RVCT9: RAM 0x20000000 size 0x10000
